RDEPENDS_${PN} += "fio-examples"
