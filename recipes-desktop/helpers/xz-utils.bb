LICENSE = "CLOSED"
LIC_FILES_CHKSUM = ""

ALLOW_EMPTY_${PN} = "1"
PROVIDES += "${PN}"
RDEPENDS_${PN} += "xz"
