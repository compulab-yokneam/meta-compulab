SRC_URI_remove = "ftp://ftp.freedesktop.org/pub/mesa/${PV}/mesa-${PV}.tar.xz"

SRC_URI_append = " \
   ftp://ftp.freedesktop.org/pub/mesa/older-versions/11.x/11.1.1/mesa-11.1.1.tar.xz \
"
