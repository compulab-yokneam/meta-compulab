SRC_URI_remove = " http://ftp.mozilla.org/pub/mozilla.org/js/${BPN}${PV}.tar.gz"

SRC_URI_append = " \
	http://ftp.mozilla.org/pub/js/mozjs17.0.0.tar.gz \
"
